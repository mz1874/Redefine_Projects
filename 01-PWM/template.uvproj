# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: RD8T36P48 RD8Txx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x1FFF) CLOCK(32000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: RD8G36x
  c include: .\libraries;.\libraries\src;.\libraries\inc
  group App
    ./: main.c
  group librariies
    ./libraries/src/: rd8_gpio.c rd8_pwm.c
    ./libraries/inc/: rd8_gpio.h rd8_pwm.h
